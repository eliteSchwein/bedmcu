File: hardware/schematic/BedMCU.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: feat: upload rev 3.1 schematic
Parts:
- H1, H2, H3, H4: now in the parts list
